# IAR project EFR32MG21_wdog.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: EFR32MG21A010F1024IM32 SiliconLaboratories EFR32MG21A010F1024IM32
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 57
  General.FPU2: 6
  ICCARM.CCDefines: EFR32MG21A010F1024IM32; RETARGET_VCOM
  ICCARM.CCIncludePath2: ..\..\..\platform\CMSIS\Include; ..\..\..\platform\Device\SiliconLabs\EFR32MG21\Include; ..\..\..\platform\emlib\inc; ..\..\..\platform\emdrv\common\inc; ..\..\..\platform\emdrv\ustimer\config; ..\..\..\platform\emdrv\ustimer\inc; ..\..\..\hardware\kit\EFR32MG21_BRD4181A\config; ..\..\..\hardware\kit\common\bsp; ..\..\..\hardware\kit\common\drivers
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: EFR32MG21A010F1024IM32; RETARGET_VCOM
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: EFR32MG21_wdog.bin
  ILINK.IlinkOutputFile: EFR32MG21_wdog.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; EFR32MG21A010F1024IM32; RETARGET_VCOM
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  AARM.ADefines: NDEBUG; EFR32MG21A010F1024IM32; RETARGET_VCOM
  group CMSIS
    ../../../platform/Device/SiliconLabs/EFR32MG21/Source/IAR/: startup_efr32mg21.s
    ../../../platform/Device/SiliconLabs/EFR32MG21/Source/: system_efr32mg21.c
  group drivers
    ../../../hardware/kit/common/drivers/: retargetio.c retargetserial.c
  group emdrv
    ../../../platform/emdrv/ustimer/src/: ustimer.c
  group emlib
    ../../../platform/emlib/src/: em_cmu.c em_emu.c em_core.c em_gpio.c em_letimer.c em_prs.c em_rmu.c em_system.c em_timer.c em_usart.c em_wdog.c
  group Source
    ../src/: main_wdog_s2.c wdog_mode_test_s2.c
